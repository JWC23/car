# Keil uVision project NUC029xAN.uvproj, settings and files
target NUC029xAN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC029LAN Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: CarPowerBank +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\Device\Nuvoton\NUC029xAN\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\source;..\source\include
  library: MicroLIB
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
    ../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group User
    ../source/: main.c adc_func.c init.c interrupts.c power.c utils.c battery.c led.c switch.c relay.c
  group Library
    ../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c timer.c adc.c gpio.c fmc.c
